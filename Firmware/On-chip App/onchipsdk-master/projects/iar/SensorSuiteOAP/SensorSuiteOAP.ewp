# IAR project SensorSuiteOAP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa039,Pa050,Pe767,Go005,Pa082,Pa089,Pe167,Pe550,Pe188,Pe177
  ICCARM.IExtraOptions: --no_path_in_file_macros; --enum_is_int
  ICCARM.PreInclude: ..\all_projects.iarinc
  ICCARM.CCIncludePath2: ..\..\..\src\app\<your_app_dir>\; ..\..\..\src\app\common\; ..\..\..\src\inc\; ..\..\..\src\modules\clilib\; ..\..\..\src\modules\ip_applib\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  postbuild: C:\Python27\python.exe "..\..\..\tools\dustElfToBin\dustElfToBin.py" "$TARGET_PATH$"
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkConfigDefines: use_loader=1
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\Linear\DustNetworks\Eterna.icf
  ILINK.IlinkProgramEntryLabel: __reset_handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  group app/common
    ../../../src/app/common/: app_cfg.h build.h cli_task.c cli_task.h loc_task.c loc_task.h Ver.h well_known_ports.h
  group app/SensorSuiteOAP
    ../../../src/app/SensorSuiteOAP/: app_task_cfg.h SensorSuite_app.c
  group inc
    ../../../src/inc/: dn_adc.h dn_api_common.h dn_api_local.h dn_api_param.h dn_channel.h dn_cli.h dn_common.h dn_errno.h dn_exe_hdr.h dn_flash_drv.h dn_flash_info.h dn_fs.h dn_gpio.h dn_hwinfo.h dn_i2c.h dn_lptimer.h dn_mem.h dn_mesh.h dn_mesh_const.h dn_onewire.h dn_pack.h dn_pwm.h dn_radio.h dn_randhw.h dn_security.h dn_spi.h dn_system.h dn_temperature.h dn_time.h dn_typedef.h dn_uart.h dn_uart_raw.h os_cfg.h os_cpu.h ucos_ii.h
  group lib
    ../../../src/lib/: libip_stack.a libucos_full.a
  group modules/clilib
    ../../../src/modules/clilib/: dnm_ucli.c dnm_ucli.h
  group modules/ip_applib
    ../../../src/modules/ip_applib/: dnm_local.c dnm_local.h dnm_rate_ctrl.c dnm_rate_ctrl.h dnm_service.c dnm_service.h
